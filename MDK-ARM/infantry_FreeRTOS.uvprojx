# Keil uVision project infantry_FreeRTOS.uvprojx, settings and files
target infantry_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: infantry_FreeRTOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,ARM_MATH_CM4,__CC_ARM,__FPU_PRESENT
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\user\Remote;..\IMU;..\user\sys;..\user\APP;..\user\Capacity;..\user\Chassis;..\user\MotorHead;..\user\PID;..\user\Ramp;..\user\Referee_system;..\user\GIMBAL;..\Src\BasicMathFunctions;..\Src\CommonTables;..\Src\FastMathFunctions;..\Src\MatrixFunctions;..\user\FILITER;..\user\DETECT;..\user\DEBUG;..\user\FUZZY_PID;..\README;..\user\ADRC;..\user\Update_IMU
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group USER
    ../user/APP/: app.c Init_Music.c
    ../user/PID/: pid.c
    ../user/Remote/: remote.c
    ../user/Capacity/: capacity.c
    ../user/Chassis/: chassis.c
    ../user/MotorHead/: motorhead.c
    ../user/GIMBAL/: gimbal.c aimauto.c
    ../user/Ramp/: ramp.c
    ../user/Referee_system/: referee_system.c
    ../user/DETECT/: detect.c
    ../user/DEBUG/: debug.c
    ../user/FUZZY_PID/: fuzzy_pid.c
    ../user/FILITER/: filter.c
    ../user/ADRC/: adrc.c
  group IMU
    ../IMU/: imu.c imu_driver.c usart_imu.c
  group Application/User
    ../Src/: main.c gpio.c adc.c can.c dma.c freertos.c spi.c tim.c rng.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ../Src/BasicMathFunctions/: arm_sub_f32.c arm_scale_f32.c arm_offset_f32.c arm_negate_f32.c arm_mult_f32.c arm_dot_prod_f32.c arm_add_f32.c arm_abs_f32.c
    ../Src/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../Src/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ../Src/MatrixFunctions/: arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group ReadMe
    ../README/: readme.txt
  group Update_IMU
    ../user/Update_IMU/: packet.c imu_data_decode.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2
